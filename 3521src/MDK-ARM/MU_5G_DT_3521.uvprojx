# Keil uVision project MU_5G_DT_3521.uvprojx, settings and files
target 3521A_MU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 3521A_MU_3F_24041201 +hex
  AfterMake: fromelf.exe --i32 -o "@L.hex" "#L"
  AfterMake: ..\size_bar_v1.0.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F427,USE_USB_FS,PRODUCT_MODEL=CMDT3521A
  c include: ..\user;..\hardware\startup;..\hardware\libs\gd32f4xx\GD32F4xx_standard_peripheral\Include;..\hardware\libs\gd32f4xx\CMSIS;..\hardware\libs\gd32f4xx\CMSIS\GD\GD32F4xx\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\device\class\cdc\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\device\core\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\driver\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\ustd\class\cdc;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\ustd\common;..\hardware\core\3521A\inc;..\hardware\include;..\hardware\interface\inc;..\Middlewares\FreeRTOS\3521A_B\FreeRTOSv10.5.1\include;..\Middlewares\FreeRTOS\3521A_B\FreeRTOSv10.5.1\portable\RVDS\ARM_CM4F;..\Middlewares\Msg_Handle;..\Middlewares\RTT_Viewer\inc;..\Middlewares\tools;..\Middlewares\OS_File\inc;..\app\modules\USB_DEVICE\3521A_B\inc;..\bsp\drivers\trx8668_fpga\inc;..\bsp\drivers\FPGA_driver\inc;..\bsp\drivers\eswin_sync_modem\inc;..\bsp\drivers\cat1_EC800G;..\bsp\interface;..\bsp\include;..\bsp\drivers;..\Middlewares\Y_Modem;..\app\bsp_flash;..\app\bsp_public;..\app\bsp_reboot;..\app\bsp_rf;..\app\bsp_wdg;..\app\bsp_led;..\app\app_version;..\app\bsp_testmode;..\app\bsp_pc;..\bsp\drivers\ble;..\app\modules\warn_process;..\app\bsp_warn;..\Middlewares\mcp_core;..\app\app_monitor;..\app\app_mu_ru_communicate
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c200 size 0x73e00
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group readme_A
    ../user/3521A/: readme_A.txt
  group readme_B
    ../user/3521B/: readme_B.txt
  group readme_C
    ../user/3521C/: readme_C.txt
  group User_config
    ../user/: system_config.h
    ../app/: app_config.h
  group User_3521A
    ../user/3521A/: main.c
  group User_3521B
    ../user/3521B/: main.c
  group User_3521C
    ../user/3521C/: main.c
  group hw/startup
    ../hardware/startup/: startup_stm32f407xx.s startup_gd32f407_427.s startup_gd32f450_470.s
  group hw/lib/gd32f4xx_std_driver
    ../hardware/libs/gd32f4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group hw/lib/STM32F4xx_HAL_Driver
    ../hardware/libs/stm32f4xx/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group hw/Core/3521A
    ../hardware/core/3521A/src/: adc.c chip.c flash.c gd32f4xx_it.c gpio.c iwdg.c spi.c systick.c tim.c usart.c
    ../hardware/libs/gd32f4xx/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../hardware/core/3521A/inc/: main.h
  group hw/Core/3521B
    ../hardware/core/3521B/src/: adc.c chip.c flash.c gd32f4xx_it.c gpio.c iwdg.c spi.c systick.c tim.c usart.c
    ../hardware/libs/gd32f4xx/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../hardware/core/3521B/Inc/: main.h
  group hw/Core/3521C
    ../hardware/core/3521C/src/: adc.c dma.c freertos.c gpio.c iwdg.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c tim.c usart.c
    ../hardware/core/3521C/inc/: main.h
  group hw/include
    ../hardware/include/: public_define.h public_enum.h public_struct.h
  group hw/interface
    ../hardware/include/: MCU_config.h
    ../hardware/interface/src/: hi_init.c hi_gpio.c hi_spi.c hi_adc.c hi_delay.c hi_flash.c hi_iwdg.c hi_system.c hi_systick.c hi_tim.c hi_uart.c hi_usb.c hi_cbuffer.c hi_dma.c hi_irq.c
  group bsp/drivers
    ../bsp/drivers/: ATT_analog.c ATT_digital.c led.c lna.c pa.c flash_25xx.c port.c switch_spdt_RFASWA630PTF06.c switch_sp4t_MXD8641H.c
  group bsp/drivers/8668
    ../bsp/drivers/trx8668_fpga/src/: ecr8668_user.c ECR8660.c ECR8660_Config.c ECR8660_Error.c ECR8660_SPI.c ecr8668.c ecr8668_driver.c bin_b3.c bin_b8.c bin_b39.c bin_b40.c bin_N41.c ecr8668_globals.c
  group bsp/drivers/FPGA
    ../bsp/drivers/FPGA_driver/src/: fpga_cfg.c fpga_clock.c fpga_ook.c fpga_ps.c fpga_spi.c fpga_task.c
  group bsp/drivers/ESWIN_SYNC_MODEM
    ../bsp/drivers/eswin_sync_modem/src/: eswin_sync_modem.c
  group bsp/drivers/cat_ec800g
    ../bsp/drivers/cat1_EC800G/: cat1_EC800G_driver.c
  group bsp/drivers/cat1_n706
    ../bsp/drivers/cat1_N706/: cat1_N706_driver.c cat1_N706_driver.h
  group bsp/drivers/cat_mc661
    ../bsp/drivers/cat1_MC661/: cat1_MC661_driver.c cat1_MC661_driver.h
  group bsp/drivers/ble
    ../bsp/drivers/ble/: ble.c
  group bsp/interface
    ../bsp/interface/: bsp_config.c bi_att.h bi_ble.h bi_led.h bi_lna.h bi_pa.h bi_port.h bi_switch_spXt.h bi_fpga.h
    ../bsp/include/: bsp_config.h
  group bsp/sys_config
    ../user/: system_config.h
  group bsp/debug
    ../bsp/debug/: bsp_shell.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/3521C/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/3521C/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/FreeRTOS/3521C/Source/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/3521C/Source/portable/RVDS/ARM_CM4F/: port.c
  group middlewares/freertos_v10.5.1
    ../Middlewares/FreeRTOS/3521A_B/FreeRTOSv10.5.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/3521A_B/FreeRTOSv10.5.1/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/3521A_B/FreeRTOSv10.5.1/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/st_usb_lib
    ../Middlewares/USB_LIB/3521C/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/USB_LIB/3521C/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/gd_usb_lib
    ../Middlewares/USB_LIB/3521A_B/GD32F4xx_usb_library/device/class/cdc/Source/: cdc_acm_core.c
    ../Middlewares/USB_LIB/3521A_B/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ../Middlewares/USB_LIB/3521A_B/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group middlewares/msg_handle
    ../Middlewares/Msg_Handle/: msg_handle.c
  group middlewares/tools
    ../Middlewares/tools/: ascii_hex.c crc.c
  group middlewares/rtt
    ../Middlewares/RTT_Viewer/src/: rtt.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group middlewares/ymodem
    ../Middlewares/Y_Modem/: Ymodem.c Ymodem.h Ymodem_port.c Ymodem_test.c
  group middlewares/mcp_core
    ../Middlewares/mcp_core/: mcp_core.c mcp_core.h mcpA_user.c mcpB_user.c mcpC_user.c monitor_para_list.c monitor_para_list.h mcpMRC_user.c mu_ru_comm_para_list.c
  group middlewares/os
    ../Middlewares/OS_File/src/: os_init.c os_task.c os_event.c os_queue.c os_semaphore.c os_timer.c
  group app/modules/gd_usb
    ../app/modules/USB_DEVICE/3521A_B/src/: gd32f4xx_hw.c
  group app/modules/st_usb
    ../app/modules/USB_DEVICE/3521C/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ../app/modules/USB_DEVICE/3521C/Target/: usbd_conf.c
  group app/flash
    ../app/bsp_flash/: bsp_dev_flash.c bsp_flash_addr.c
  group app/rf
    ../app/bsp_rf/: bsp_dev_para.c bsp_para_load.c bsp_rf_4g_band_sel.c bsp_rf_5g_modem.c bsp_rf_alc.c bsp_rf_att.c bsp_rf_att_set.c bsp_rf_brd.c bsp_rf_cali.c bsp_rf_ctr.c bsp_rf_dc_switch.c bsp_rf_dev_state.c bsp_rf_get_para.c bsp_rf_global.c bsp_rf_lna.c bsp_rf_oplc.c bsp_rf_pa.c bsp_rf_pow.c bsp_rf_slave.c bsp_rf_switch.c bsp_rf_time.c bsp_rf_workmode.c bsp_temperature.c bsp_up_silence.c bsp_rf_power_on.c bsp_rf_866x.c bsp_rf_866x_default_set.c bsp_rf_fpga.c bsp_rf_scan_net.c bsp_rf_iso.c
  group app/testmode
    ../app/bsp_testmode/: bsp_testmode.c bsp_testmode_analysis.c bsp_testmode_data_rw.c bsp_testmode_ergodic.c bsp_testmode_hal_set.c bsp_testmode_para_list.c bsp_testmode_save.c
  group app/reboot
    ../app/bsp_reboot/: bsp_reboot.c
  group app/wdg
    ../app/bsp_wdg/: bsp_wdg.c
  group app/public
    ../app/bsp_public/: bsp_public_drv.c bsp_public_drv.h
  group app/pc
    ../app/bsp_pc/: bsp_pc.c uart_at_cmd.c
  group app/modules/warn_core
    ../app/modules/warn_process/: warn_core.c
  group app/warn
    ../app/bsp_warn/: bsp_warn_user.c
  group app/monitor
    ../app/app_monitor/: app_monitor.c app_monitor_report.c
  group app/mu_ru_communicate
    ../app/app_mu_ru_communicate/: mu_ru_communicate.c mu_ru_communicate.h ru_device_list.c ru_device_list.h
  group app/led
    ../app/bsp_led/: led_display.c led_display.h
  group app/version
    ../app/app_version/: app_upgrade.c app_version.c
target 3521B_MU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: as above
  output: 3521B_MU_3F_2404112 +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  AfterMake: ..\size_bar_v1.0.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F427,USE_USB_FS,PRODUCT_MODEL=CMDT3521B
  c include: ..\user;..\hardware\startup;..\hardware\libs\gd32f4xx\GD32F4xx_standard_peripheral\Include;..\hardware\libs\gd32f4xx\CMSIS;..\hardware\libs\gd32f4xx\CMSIS\GD\GD32F4xx\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\device\class\cdc\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\device\core\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\driver\Include;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\ustd\class\cdc;..\Middlewares\USB_LIB\3521A_B\GD32F4xx_usb_library\ustd\common;..\hardware\core\3521B\inc;..\hardware\include;..\hardware\interface\inc;..\Middlewares\FreeRTOS\3521A_B\FreeRTOSv10.5.1\include;..\Middlewares\FreeRTOS\3521A_B\FreeRTOSv10.5.1\portable\RVDS\ARM_CM4F;..\Middlewares\Msg_Handle;..\Middlewares\RTT_Viewer\inc;..\Middlewares\tools;..\Middlewares\OS_File\inc;..\app\modules\USB_DEVICE\3521A_B\inc;..\bsp\drivers\trx8668_fpga\inc;..\bsp\drivers\FPGA_driver\inc;..\bsp\drivers\eswin_sync_modem\inc;..\bsp\interface;..\bsp\include;..\bsp\drivers;..\Middlewares\Y_Modem;..\app\bsp_flash;..\app\bsp_public;..\app\bsp_reboot;..\app\bsp_rf;..\app\bsp_wdg;..\app\bsp_led;..\app\app_version;..\app\bsp_testmode;..\app\bsp_pc;..\bsp\drivers\cat1_N706;..\bsp\drivers\ble;..\app\modules\warn_process;..\app\bsp_warn;..\Middlewares\mcp_core;..\app\app_monitor;..\app\app_mu_ru_communicate
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c200 size 0x73e00
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target 3521C_MU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 3521C_MU_5F_24041301 +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  AfterMake: ..\size_bar_v1.0.exe
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PRODUCT_MODEL=CMDT3521C
  c include: ..\Hardware\libs\stm32f4xx\STM32F4xx_HAL_Driver\Inc;..\Hardware\libs\stm32f4xx\STM32F4xx_HAL_Driver\Inc\Legacy;..\Hardware\libs\stm32f4xx\CMSIS\Device\ST\STM32F4xx\Include;..\Hardware\libs\stm32f4xx\CMSIS\Include;..\Hardware\core\3521C\inc;..\Hardware\interface\inc;..\Hardware\include;..\User;..\bsp\include;..\bsp\drivers;..\bsp\interface;..\app\modules\USB_DEVICE\3521C\App;..\app\modules\USB_DEVICE\3521C\Target;..\Middlewares\USB_LIB\3521C\STM32_USB_Device_Library\Class\CDC\Inc;..\Middlewares\USB_LIB\3521C\STM32_USB_Device_Library\Core\Inc;..\Middlewares\Msg_Handle;..\Middlewares\FreeRTOS\3521C\Source\CMSIS_RTOS_V2;..\Middlewares\FreeRTOS\3521C\Source\include;..\Middlewares\FreeRTOS\3521C\Source\portable\RVDS\ARM_CM4F;..\bsp\drivers\ble;..\Middlewares\Msg_Handle;..\Middlewares\OS_File\inc;..\Middlewares\RTT_Viewer\inc;..\Middlewares\Y_Modem;..\bsp\drivers\trx8668_fpga;..\bsp\drivers\trx8668_fpga\inc;..\bsp\drivers\FPGA_driver\inc;..\bsp\drivers\eswin_sync_modem\inc;..\app\bsp_flash;..\app\bsp_led;..\app\bsp_public;..\app\bsp_reboot;..\app\bsp_rf;..\app\app_version;..\app\bsp_wdg;..\app\bsp_testmode;..\app\bsp_pc;..\bsp\drivers\cat1_MC661;..\Middlewares\tools;..\app\modules\warn_process;..\app\bsp_warn;..\Middlewares\mcp_core;..\app\app_monitor;..\app\app_mu_ru_communicate
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c200 size 0x73e00
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\3521C\3521C_MU_Upgrade.sct
software components: CMSIS:CORE 5.6.0
